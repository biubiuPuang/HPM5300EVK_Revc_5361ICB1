# IAR project gpio_example.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM5361xCBx HPMicro HPM5361xCBx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEO=y; HPMSOC_HAS_HPMSDK_MMC=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_DAC=y; HPMSOC_HAS_HPMSDK_OPAMP=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y
  ICCRISCV.CCIncludePath2: ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/arch; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/arch/riscv/l1c; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/arch/riscv/intc; ../../../../board/hpm5300evk; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/ip; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361/toolchains; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361/boot; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/drivers/inc; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/utils; ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/components/debug_console; ../build_tmp/generated/include
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=1M
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\1_Sofrware\HPM5300_SoftWare\sdk_env_v1.11.0\sdk_env_v1.11.0\hpm_sdk\soc\HPM5300\HPM5361\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEO=y; HPMSOC_HAS_HPMSDK_MMC=y; HPMSOC_HAS_HPMSDK_PWM=y; HPMSOC_HAS_HPMSDK_RDC=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_SEI=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_SDP=y; HPMSOC_HAS_HPMSDK_SEC=y; HPMSOC_HAS_HPMSDK_MON=y; HPMSOC_HAS_HPMSDK_RNG=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_KEYM=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_DAC=y; HPMSOC_HAS_HPMSDK_OPAMP=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PMP=y; NDEBUG
  group application/src
    D:/_Project/HPM5300EVK_Revc/SDK_Project/app/gpio/src/: gpio.c
  group soc/HPM5300/HPM5361
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c hpm_qeiv2_soc_drv.c
  group soc/HPM5300/HPM5361/toolchains
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM5300/HPM5361/toolchains/iar
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361/toolchains/iar/: startup.s
  group soc/HPM5300/HPM5361/boot
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/soc/HPM5300/HPM5361/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm5300evk
    D:/_Project/HPM5300EVK_Revc/SDK_Project/board/hpm5300evk/: pinmux.c board.c
  group drivers/src
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/drivers/src/: hpm_uart_drv.c hpm_sdp_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_rng_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwm_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_acmp_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_tsns_drv.c hpm_dac_drv.c hpm_crc_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_sei_drv.c hpm_qeo_drv.c hpm_rdc_drv.c hpm_mmc_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_opamp_drv.c
  group utils
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../../../1_Sofrware/HPM5300_SoftWare/sdk_env_v1.11.0/sdk_env_v1.11.0/hpm_sdk/components/debug_console/: hpm_debug_console.c
